# Keil uVision project XXX.uvproj, settings and files
target mbed NXP LPC1768 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: DigitalOut_HelloWorld
  AfterMake: fromelf --bin -o build\DigitalOut_HelloWorld_LPC1768.bin build\DigitalOut_HelloWorld.axf
  c flags: Optim=1
  c define: TARGET_FF_ARDUINO,  __CORTEX_M3,  MBED_BUILD_TIMESTAMP=1455792095.59,  ARM_MATH_CM3,  TARGET_LIKE_CORTEX_M3,  TARGET_CORTEX_M,  TARGET_LIKE_MBED,  TARGET_LPC176X,  TARGET_NXP,  TARGET_ARCH_PRO,  __MBED__=1,  TARGET_LPC1768,  TARGET_M3,  TOOLCHAIN_ARM,  TOOLCHAIN_ARM_STD,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  mbed;  mbed/TARGET_ARCH_PRO;  mbed/TARGET_ARCH_PRO/TARGET_NXP;  mbed/TARGET_ARCH_PRO/TARGET_NXP/TARGET_LPC176X;  mbed/TARGET_ARCH_PRO/TARGET_NXP/TARGET_LPC176X/TARGET_ARCH_PRO;  mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  scatter file: mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD/LPC1768.sct
  link misc: mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD/startup_LPC17xx.o
            
              mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD/system_LPC17xx.o
            
              mbed/TARGET_ARCH_PRO/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    ./: main.cpp
